Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Project Number
Time: 2026-03-17T00:49:36
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 22.0.2.392 - Exporter 22.0.2.392 - Alternate UI 22.0.2.392
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Tue Mar 17 00:49:36 2026 * Host: Yoga * Database: D:\Temp\ba28f502-3be8-4f53-a906-ba9e9b79f889\eef7014a-10cd-4d1f-820c-353047f5bb29\ifc * Database version: 5507 * Database creation date: Tue Mar 17 00:49:34 2026 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Tue Mar 17 00:49:34 2026 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Tue Mar 17 00:49:34 2026 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 51, 30, 23, 112487; RefLongitude: 0, -7, -37, -956022; RefElevation: 0 mm
Pset_ProductRequirements - Category: Project Information
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Pset_ProductRequirements - Category: Project Information
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuildingStorey: Level:Circle Head - Project Datum, Level 0
LongName: Level 0; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: Circle Head - Project Datum
Graphics(Type) - Color: 0; Line Pattern: Centre; Line Weight: 1; Symbol: Anno_Level_Head_Circle: Standard; Symbol at End 1 Default: yes; Symbol at End 2 Default: no
Constraints(Type) - Elevation Base: Project Base Point
Pset_AirSideSystemInformation - Name: Level 0
Pset_ProductRequirements - Name: Level 0; Category: Levels
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 0; Structural: no
Other - Category: Levels; Family: Level: Circle Head - Project Datum; Family and Type: Level: Circle Head - Project Datum; Type: Level: Circle Head - Project Datum; Type Id: Level: Circle Head - Project Datum

# IfcFlowController: BC5083-15:BC5083-15, BC5083-15:BC5083-15:588811
In: Level 0
Type - PredefinedType: MIXING; Material: <Unnamed>
Type - Constraints - Default Elevation: 0 mm
Type - Identity Data - AccessibilityPerformance: n/a; AssetIdentifier: n/a; AssetType: Fixed; BarCode: n/a; Category: Pr_40_20_87_78:Shower manual water supply sets; CodePerformance: WRAS_TMV3; Color: Chrome; Constituents: n/a; Description: ShowerValveExposed; DurationUnit: year; ExpectedLife: n/a; Features: n/a; Finish: Chrome; IfcExportAs: IfcValveType; IfcExportType: MIXING; InstallationDate: 31-12-1900 23:59; Manufacturer: info@dolphinsolutions.co.uk; ManufacturerName: DolphinsolutionsLimited; ManufacturerURL: http://www.dolphinsolutions.co.uk/; Material: Body_Elbows/ChromePlatedPolishedBrass_Lever/ChromePlatedZincDieCast; ModelNumber: BC5083-15; ModelReference: DolphinSolutionsLimited_ShowerManualWaterSupplySets_ShowerValveExpposed; Name: ShowerManualWaterSupplySets_ShowerValveExposed_BC5083-15_DolphinSolutionsLimited; NBSDescription: Showers; NBSReference: 45-35-70/333; NominalHeight: 109 mm; NominalLength: 122 mm; NominalWidth: 205 mm; ObjectClassification1: OmniClass; ObjectClassification2: 23.45.05.14.17; ReplacementCost: n/a; Size: 205x122x109; SustainabilityPerformance: n/a; TagNumber: n/a; Type Name: BC5083-15; Uniclass2015Code: Pr_40_20_87_78; Uniclass2015Title: Shower manual water supply sets; WarrantyDescription: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: year; WarrantyGuarantorLabor: DolphinSolutionsLimited; WarrantyGuarantorParts: DolphinSolutionsLimited; WarrantyStartDate: 31-12-1900 23:59
Type - Other - Category: Plumbing Fixtures; Family Name: BC5083-15
Type - Pset_ElementShading - Color: Chrome
Type - Pset_ManufacturerOccurrence - BarCode: n/a
Type - Pset_ManufacturerTypeInformation - ModelReference: DolphinSolutionsLimited_ShowerManualWaterSupplySets_ShowerValveExpposed; Manufacturer: info@dolphinsolutions.co.uk
Type - Pset_ProductRequirements - Name: ShowerManualWaterSupplySets_ShowerValveExposed_BC5083-15_DolphinSolutionsLimited; Category: Pr_40_20_87_78:Shower manual water supply sets
Pset_DistributionFlowElementCommon - Reference: BC5083-15:BC5083-15; sets with these values: 2
Pset_ProductRequirements - Category: Plumbing Fixtures
Constraints - Level: Level: Level 0; Moves With Nearby Elements: no; Elevation from Level: 800 mm; Host: Level : Level 0; Offset from Host: 800 mm
Dimensions - Area: 0.0287295 m2; Volume: 0.000522682 m3
Identity Data - Mark: 317
Other - Family: BC5083-15: BC5083-15; Family and Type: BC5083-15: BC5083-15; Type: BC5083-15: BC5083-15; Type Id: BC5083-15: BC5083-15
Phasing - Phase Created: New Construction

# IfcFlowTerminal: BC5083-02:BC5083-02 (3)
In: Level 0
Type - Material: <Unnamed>
Type - Constraints - Default Elevation: 1219.2 mm
Type - Dimensions - Depth: 76 mm; Diameter: 32 mm; Width: 600 mm
Type - Identity Data - AccessibilityPerformance: n/a; AssetIdentifier: n/a; AssetType: Fixed; BarCode: n/a; Category: Pr_40_20_76_84:SupportRails; CodePerformance: BSEN12182; Color: Brushed Satin; Constituents: n/a; Description: 600mm long 32mm Grab Rail 75mm Rosettes; DurationUnit: year; ExpectedLife: n/a; Features: 50mm wall clearance; Finish: Brushed Satin; Form: Wall-mounted; Grade: 304; InstallationDate: 31-12-1900 23:59; Manufacturer: mailto:info@dolphinsolutions.co.uk; ManufacturerName: DolphinsolutionsLimited; ManufacturerURL: http://www.dolphinsolutions.co.uk/; Material: StainlessSteel; ModelNumber: BC5083-02; ModelReference: DolphinSolutionsLimited_32mmGrabRail; Name: SupportRails_32mmGrabRail_BC5083-02_DolphinSolutionsLimited; NBSDescription: Support rails; NBSReference: 45-35-72/360; NBSTypeID: n/a; NominalHeight: 82 mm; NominalLength: 600 mm; NominalWidth: 32 mm; ObjectClassification_1: OmniClass; ObjectClassification_2: 23.40.20.27.14; ProductInformation: https://www.dolphinsolutions.co.uk/product/dolphin-stainless-steel-grab-rail-2/; ReplacementCost: n/a; Revision: n/a; SerialNumber: n/a; Shape: n/a; Size: 600 x 32 x 82 mm; SustainabilityPerformance: n/a; TagNumber: n/a; Type Name: BC5083-02; Uniclass2015Code: Pr_40_20_76_84; Uniclass2015Title: Support rails; WarrantyDescription: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a; WarrantyStartDate: 31-12-1900 23:59
Type - Other - Category: Plumbing Fixtures; Family Name: BC5083-02
Type - Pset_ElementShading - Color: Brushed Satin
Type - Pset_ManufacturerOccurrence - BarCode: n/a; SerialNumber: n/a
Type - Pset_ManufacturerTypeInformation - ModelReference: DolphinSolutionsLimited_32mmGrabRail; Manufacturer: mailto:info@dolphinsolutions.co.uk
Type - Pset_ProductRequirements - Name: SupportRails_32mmGrabRail_BC5083-02_DolphinSolutionsLimited; Category: Pr_40_20_76_84:SupportRails
Pset_DistributionFlowElementCommon - Reference: BC5083-02:BC5083-02; sets with these values: 2
Pset_ProductRequirements - Category: Plumbing Fixtures
Constraints - Level: Level: Level 0; Moves With Nearby Elements: no; Host: Level : Level 0
Dimensions - Area: 0.0760405 m2; Volume: 0.000185759 m3
Other - Family: BC5083-02: BC5083-02; Family and Type: BC5083-02: BC5083-02; Type: BC5083-02: BC5083-02; Type Id: BC5083-02: BC5083-02
Phasing - Phase Created: New Construction
Name (BC5083-02:BC5083-02:...) | Elevation from Level (mm) = Offset from Host (mm) | Mark
588798 | 665 | 304
588799 | 665 | 305
588804 | 1100 | 310

# IfcFlowTerminal: BC5083-04PSS-BC5083-25:BC5083-04PSS/BC5083-25, BC5083-04PSS-BC5083-25:BC5083-04PSS/BC5083-25:588806
In: Level 0
Type - PredefinedType: USERDEFINED; Material: <Unnamed>
Type - Constraints - Default Elevation: 0 mm
Type - Dimensions - Height: 900 mm
Type - Identity Data - AccessibilityPerformance: n/a; AssetIdentifier: n/a; AssetType: Fixed; BarCode: n/a; Category: Pr_40_20_87_75:Shower fittings package; CodePerformance: BS EN 12182; Color: MirrorPolished; Constituents: n/a; Description: Shower riser rail and bracket; DurationUnit: year; ExpectedLife: n/a; Features: n/a; Finish: Polished; Grade: 304; IfcExportAs: IfcSanitaryTerminalType; IfcExportType: USERDEFINED; InstallationDate: 31-12-1900 23:59; Manufacturer: info@dolphinsolutions.co.uk; ManufacturerName: DolphinsolutionsLimited; ManufacturerURL: http://www.dolphinsolutions.co.uk/; Material: StainlessSteel; ModelNumber: BC5083-04PSS/BC5083-25; ModelReference: ShowerFittingsPackage_DolphinSolutionsLimited_WRAS_BC5083-04PSS/BC5083-25; Name: ShowerFittingsPackage_WRAS_BC5083-04PSS/BC5083-25_ShowerRiserRailAndBracket_DolphinSolutionsLimited; NBSDescription: Showers; NBSReference: 45-35-70/333; NominalHeight: 92 mm; NominalLength: 900 mm; NominalWidth: 32 mm; ObjectClassification1: OmniClass; ObjectClassification2: 23.45.05.14.17; OmniClass Number: 23.45.00.00; OmniClass Title: Sanitary, Laundry, and Cleaning Equipment; Product Information: https://www.dolphinsolutions.co.uk/product/8173/; ReplacementCost: n/a; Shape: n/a; Size: 32x900x92; SustainabilityPerformance: n/a; TagNumber: n/a; Type Name: BC5083-04PSS/BC5083-25; Uniclass2015Code: Pr_40_20_87_75; Uniclass2015Title: Shower fittings package; WarrantyDescription: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: year; WarrantyGuarantorLabor: DolphinSolutionsLimited; WarrantyGuarantorParts: DolphinSolutionsLimited; WarrantyStartDate: 31-12-1900 23:59
Type - Other - Category: Plumbing Fixtures; Family Name: BC5083-04PSS-BC5083-25
Type - Pset_ElementShading - Color: MirrorPolished
Type - Pset_ManufacturerOccurrence - BarCode: n/a
Type - Pset_ManufacturerTypeInformation - ModelReference: ShowerFittingsPackage_DolphinSolutionsLimited_WRAS_BC5083-04PSS/BC5083-25; Manufacturer: info@dolphinsolutions.co.uk
Type - Pset_ProductRequirements - Name: ShowerFittingsPackage_WRAS_BC5083-04PSS/BC5083-25_ShowerRiserRailAndBracket_DolphinSolutionsLimited; Category: Pr_40_20_87_75:Shower fittings package
Pset_DistributionFlowElementCommon - Reference: BC5083-04PSS-BC5083-25:BC5083-04PSS/BC5083-25; sets with these values: 2
Pset_ProductRequirements - Category: Plumbing Fixtures
Constraints - Level: Level: Level 0; Moves With Nearby Elements: no; Elevation from Level: 850 mm; Host: Level : Level 0; Offset from Host: 850 mm
Dimensions - Area: 0.0787353 m2; Volume: 0.0010624 m3
Identity Data - Mark: 312
Other - Family: BC5083-04PSS-BC5083-25: BC5083-04PSS/BC5083-25; Family and Type: BC5083-04PSS-BC5083-25: BC5083-04PSS/BC5083-25; Type: BC5083-04PSS-BC5083-25: BC5083-04PSS/BC5083-25; Type Id: BC5083-04PSS-BC5083-25: BC5083-04PSS/BC5083-25
Phasing - Phase Created: New Construction

# IfcFlowTerminal: BC5083-101:Standard, BC5083-101:Standard:588801
In: Level 0
Type - Material: <Unnamed>
Type - Constraints - Default Elevation: 0 mm
Type - Dimensions - Depth: 10 mm; Height: 1000 mm; Width: 400 mm
Type - Identity Data - AccessibilityPerformance: n/a; AssetIdentifier: n/a; AssetType: Fixed; BarCode: n/a; Category: Pr_25_71_53_06:Bathroom mirrors; CodePerformance: n/a; Color: n/a; Constituents: n/a; DurationUnit: year; ExpectedLife: n/a; Features: n/a; Finish: n/a; Form: Wall-mounted; Grade: n/a; InstallationDate: 31-12-1900 23:59; ManufacturerName: DolphinsolutionsLimited; ManufacturerURL: http://www.dolphinsolutions.co.uk/; Material: Glass; ModelNumber: BC5083-101; ModelReference: DolphinSolutionsLimited_Mirror; Name: BathroomMirrors_Mirror_BC5083-101_DolphinSolutionsLimited; NBSDescription: Bathroom mirrors; NBSReference: 45-35-72/336; NBSTypeID: n/a; NominalHeight: 1000; NominalLength: 15; NominalWidth: 400; ObjectClassification_1: OmniClass; ObjectClassification_2: 23.40.95.17.17; OmniClass Number: 23.45.05.21.11; OmniClass Title: Water Closets; ReplacementCost: n/a; Revision: n/a; SerialNumber: n/a; Shape: Rectangular; Size: 400 x 1000 x 15 mm; SustainabilityPerformance: n/a; TagNumber: n/a; Type Name: Standard; Uniclass2015Code: Pr_25_71_53_06; Uniclass2015Title: Bathroom mirrors; WarrantyDescription: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a; WarrantyStartDate: 31-12-1900 23:59
Type - Other - Category: Plumbing Fixtures; Family Name: BC5083-101
Type - Pset_ElementShading - Color: n/a
Type - Pset_ManufacturerOccurrence - BarCode: n/a; SerialNumber: n/a
Type - Pset_ManufacturerTypeInformation - ModelReference: DolphinSolutionsLimited_Mirror
Type - Pset_ProductRequirements - Name: BathroomMirrors_Mirror_BC5083-101_DolphinSolutionsLimited; Category: Pr_25_71_53_06:Bathroom mirrors
Pset_DistributionFlowElementCommon - Reference: BC5083-101:Standard; sets with these values: 2
Pset_ProductRequirements - Category: Plumbing Fixtures
Constraints - Level: Level: Level 0; Moves With Nearby Elements: no; Elevation from Level: 600 mm; Host: Level : Level 0; Offset from Host: 600 mm
Dimensions - Area: 0.827875 m2; Volume: 0.004 m3
Identity Data - Mark: 307
Other - Family: BC5083-101: Standard; Family and Type: BC5083-101: Standard; Type: BC5083-101: Standard; Type Id: BC5083-101: Standard
Phasing - Phase Created: New Construction

# IfcFlowTerminal: BC5083-121:Standard, BC5083-121:Standard:588800
In: Level 0
Type - Material: <Unnamed>
Type - Constraints - Default Elevation: 0 mm
Type - Dimensions - Height: 2500 mm
Type - Identity Data - AccessibilityPerformance: n/a; AssetIdentifier: n/a; AssetType: Fixed; BarCode: n/a; Category: Pr_75_75_04_04:AssistanceCallPulCordUnits; CodePerformance: BS8300:DocM; Color: Brushed Satin; Constituents: n/a; DurationUnit: year; ExpectedLife: n/a; Features: BS8300:DocM_PullCord_OpenDoorIndicator_ResetButton; Finish: Brushed Satin; Form: Surface-mounted; Grade: 304; InstallationDate: 31-12-1900 23:59; ManufacturerName: DolphinsolutionsLimited; ManufacturerURL: http://www.dolphinsolutions.co.uk/; Material: StainlessSteel; ModelNumber: BC5083-121; ModelReference: DolphinSolutionsLimited_AssistanceCallPulCordUnit; Name: AssistanceCallPulCordUnits_AssistanceCallPulCordUnit_BC5083-121_DolphinSolutionsLimited; NBSDescription: AssistanceCallPulCordUnits; NBSReference: 90-70-05/320; NBSTypeID: n/a; NominalHeight: 0; NominalLength: 0; NominalWidth: 0; ObjectClassification_1: OmniClass; ObjectClassification_2: 23.85.30.24.11; Operation: PullCord; ProductInformation: https://www.nationalbimlibrary.com/en-gb/vox-ignis-limited/vilx-cpp-assist-call-pull-cord-plate/?lo=en-GB; ReplacementCost: n/a; Revision: n/a; SerialNumber: n/a; Shape: n/a; Size: n/a; SustainabilityPerformance: n/a; TagNumber: n/a; Type Name: Standard; Uniclass2015Code: Pr_75_75_04_04; Uniclass2015Title: AssistanceCallPulCordUnits; Uniclass2015Version: Products v1.15; Version: 1; WarrantyDescription: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a; WarrantyStartDate: 31-12-1900 23:59
Type - Other - Category: Plumbing Fixtures; Family Name: BC5083-121
Type - Pset_ElementShading - Color: Brushed Satin
Type - Pset_ManufacturerOccurrence - BarCode: n/a; SerialNumber: n/a
Type - Pset_ManufacturerTypeInformation - ModelReference: DolphinSolutionsLimited_AssistanceCallPulCordUnit
Type - Pset_ProductRequirements - Name: AssistanceCallPulCordUnits_AssistanceCallPulCordUnit_BC5083-121_DolphinSolutionsLimited; Category: Pr_75_75_04_04:AssistanceCallPulCordUnits
Pset_DistributionFlowElementCommon - Reference: BC5083-121:Standard; sets with these values: 2
Pset_ProductRequirements - Category: Plumbing Fixtures
Constraints - Level: Level: Level 0; Moves With Nearby Elements: no; Elevation from Level: 0 mm; Host: Level : Level 0; Offset from Host: 0 mm
Dimensions - Area: 0.0221672 m2; Volume: 0.000127718 m3
Identity Data - Mark: 306
Other - Family: BC5083-121: Standard; Family and Type: BC5083-121: Standard; Type: BC5083-121: Standard; Type Id: BC5083-121: Standard
Phasing - Phase Created: New Construction

# IfcFlowTerminal: BC5083-16:BC5083-16, BC5083-16:BC5083-16:588810
In: Level 0
Type - PredefinedType: SHOWER; Material: <Unnamed>
Type - Constraints - Default Elevation: 0 mm
Type - Identity Data - AccessibilityPerformance: n/a; AssetIdentifier: n/a; AssetType: Fixed; BarCode: n/a; Category: Pr_40_20_87_75:Shower fittings package; CodePerformance: WRAS; Color: Chrome; Constituents: n/a; Description: Two way diverter; DurationUnit: year; ExpectedLife: n/a; Features: 1/2"BSP_connection; Finish: Chrome; IfcExportAs: IfcSanitaryTerminalType; IfcExportType: SHOWER; InstallationDate: 31-12-1900 23:59; Manufacturer: info@dolphinsolutions.co.uk; ManufacturerName: DolphinsolutionsLimited; ManufacturerURL: http://www.dolphinsolutions.co.uk/; Material: Body/ChromePlatedPolishedBrass_Lever/ChromePlatedZincDieCast; ModelNumber: BC5083-16; ModelReference: ShowerFittingsPackages_DolphinSolutionsLimited_WRAS_BC5083-16; Name: ShowerFittingsPackages_WRAS_BC5083-16_TwoWayDiverter_DolphinSolutionsLimited; NBSDescription: Showers; NBSReference: 45-35-70/333; NominalHeight: 47 mm; NominalLength: 70 mm; NominalWidth: 70 mm; ObjectClassification1: OmniClass; ObjectClassification2: 23.45.05.14.17; OmniClass Number: 23.45.00.00; OmniClass Title: Sanitary, Laundry, and Cleaning Equipment; ReplacementCost: n/a; Shape: Round; Size: 70x70x47 mm; SustainabilityPerformance: n/a; TagNumber: n/a; Type Name: BC5083-16; Uniclass2015Code: Pr_40_20_87_75; Uniclass2015Title: Shower fittings package; WarrantyDescription: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: year; WarrantyGuarantorLabor: DolphinSolutionsLimited; WarrantyGuarantorParts: DolphinSolutionsLimited; WarrantyStartDate: 31-12-1900 23:59
Type - Other - Category: Plumbing Fixtures; Family Name: BC5083-16
Type - Pset_ElementShading - Color: Chrome
Type - Pset_ManufacturerOccurrence - BarCode: n/a
Type - Pset_ManufacturerTypeInformation - ModelReference: ShowerFittingsPackages_DolphinSolutionsLimited_WRAS_BC5083-16; Manufacturer: info@dolphinsolutions.co.uk
Type - Pset_ProductRequirements - Name: ShowerFittingsPackages_WRAS_BC5083-16_TwoWayDiverter_DolphinSolutionsLimited; Category: Pr_40_20_87_75:Shower fittings package
Type - Pset_SanitaryTerminalTypeShower - Color: Chrome
Pset_DistributionFlowElementCommon - Reference: BC5083-16:BC5083-16; sets with these values: 2
Pset_ElementShading - sets with these values: 2
Pset_ProductRequirements - Category: Plumbing Fixtures
Constraints - Level: Level: Level 0; Moves With Nearby Elements: no; Elevation from Level: 900 mm; Host: Level : Level 0; Offset from Host: 900 mm
Dimensions - Area: 0.0144412 m2; Volume: 0.000126831 m3
Identity Data - Mark: 316
Other - Family: BC5083-16: BC5083-16; Family and Type: BC5083-16: BC5083-16; Type: BC5083-16: BC5083-16; Type Id: BC5083-16: BC5083-16
Phasing - Phase Created: New Construction

# IfcFlowTerminal: BC5083-18:BC5083-18, BC5083-18:BC5083-18:588809
In: Level 0
Type - PredefinedType: USERDEFINED; Material: <Unnamed>
Type - Constraints - Default Elevation: 0 mm
Type - Dimensions - Height: 800 mm
Type - Identity Data - AccessibilityPerformance: n/a; AssetIdentifier: n/a; AssetType: Fixed; BarCode: n/a; Category: Pr_40_20_87_75:Shower fittings package; CodePerformance: WRAS; Constituents: n/a; Description: Copper Tube; DurationUnit: year; ExpectedLife: n/a; Features: n/a; Finish: n/a; Grade: n/a; IfcExportAs: IfcSanitaryTerminalType; IfcExportType: USERDEFINED; InstallationDate: 31-12-1900 23:59; Manufacturer: info@dolphinsolutions.co.uk; ManufacturerName: DolphinsolutionsLimited; ManufacturerURL: http://www.dolphinsolutions.co.uk/; Material: Copper; ModelNumber: BC5083-18; ModelReference: ShowerFittingsPackage_DolphinSolutionsLimited_WRAS_BC5083-18; Name: ShowerFittingsPackage_WRAS_BC5083-18_ShowerArm_DolphinSolutionsLimited; NBSDescription: Showers; NBSReference: 45-35-70/333; NominalHeight: 0; NominalLength: n/a; NominalWidth: 0; ObjectClassification1: OmniClass; ObjectClassification2: 23.45.05.14.17; ReplacementCost: n/a; Shape: n/a; Size: n/a; SustainabilityPerformance: n/a; TagNumber: n/a; Type Name: BC5083-18; Uniclass2015Code: Pr_40_20_87_75; Uniclass2015Title: Shower fittings package; WarrantyDescription: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: year; WarrantyGuarantorLabor: DolphinSolutionsLimited; WarrantyGuarantorParts: DolphinSolutionsLimited; WarrantyStartDate: 31-12-1900 23:59
Type - Other - Category: Plumbing Fixtures; Family Name: BC5083-18
Type - Pset_ManufacturerOccurrence - BarCode: n/a
Type - Pset_ManufacturerTypeInformation - ModelReference: ShowerFittingsPackage_DolphinSolutionsLimited_WRAS_BC5083-18; Manufacturer: info@dolphinsolutions.co.uk
Type - Pset_ProductRequirements - Name: ShowerFittingsPackage_WRAS_BC5083-18_ShowerArm_DolphinSolutionsLimited; Category: Pr_40_20_87_75:Shower fittings package
Pset_DistributionFlowElementCommon - Reference: BC5083-18:BC5083-18; sets with these values: 2
Pset_ProductRequirements - Category: Plumbing Fixtures
Constraints - Level: Level: Level 0; Moves With Nearby Elements: no; Elevation from Level: 944.542 mm; Host: Level : Level 0; Offset from Host: 944.542 mm
Dimensions - Area: 0.0339928 m2; Volume: 0.0000508914 m3
Identity Data - Mark: 315
Other - Family: BC5083-18: BC5083-18; Family and Type: BC5083-18: BC5083-18; Type: BC5083-18: BC5083-18; Type Id: BC5083-18: BC5083-18
Phasing - Phase Created: New Construction

# IfcFlowTerminal: BC5083-24:BC5083-24, BC5083-24:BC5083-24:588808
In: Level 0
Type - PredefinedType: SHOWER; Material: <Unnamed>
Type - Constraints - Default Elevation: 0 mm
Type - Identity Data - AccessibilityPerformance: n/a; AssetIdentifier: n/a; AssetType: Fixed; BarCode: n/a; Category: Pr_40_20_87_76:Shower heads; CodePerformance: WRAS; Color: Chrome; Constituents: n/a; Description: Shower handset and hose; DurationUnit: year; ExpectedLife: n/a; Finish: ChromePlated; IfcExportAs: IfcSanitaryTerminalType; IfcExportType: SHOWER; InstallationDate: 31-12-1900 23:59; Manufacturer: info@dolphinsolutions.co.uk; ManufacturerName: DolphinsolutionsLimited; ManufacturerURL: http://www.dolphinsolutions.co.uk/; ModelNumber: BC5083-24; ModelReference: ShowerHeads_DolphinSolutionsLimited_WRAS_BC5083-24; Name: ShowerHeads_WRAS_BC5083-24_ShowerHandsetAndHose_DolphinSolutionsLimited; NBSDescription: Showers; NBSReference: 45-35-70/333; ObjectClassification1: OmniClass; ObjectClassification2: 23.45.05.14.17; OmniClass Number: 23.45.00.00; OmniClass Title: Sanitary, Laundry, and Cleaning Equipment; ReplacementCost: n/a; SustainabilityPerformance: n/a; TagNumber: n/a; Type Name: BC5083-24; Uniclass2015Code: Pr_40_20_87_76; Uniclass2015Title: Shower heads; WarrantyDescription: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: year; WarrantyGuarantorLabor: DolphinSolutionsLimited; WarrantyGuarantorParts: DolphinSolutionsLimited; WarrantyStartDate: 31-12-1900 23:59
Type - Other - Category: Plumbing Fixtures; Family Name: BC5083-24
Type - Pset_ElementShading - Color: Chrome
Type - Pset_ManufacturerOccurrence - BarCode: n/a
Type - Pset_ManufacturerTypeInformation - ModelReference: ShowerHeads_DolphinSolutionsLimited_WRAS_BC5083-24; Manufacturer: info@dolphinsolutions.co.uk
Type - Pset_ProductRequirements - Name: ShowerHeads_WRAS_BC5083-24_ShowerHandsetAndHose_DolphinSolutionsLimited; Category: Pr_40_20_87_76:Shower heads
Type - Pset_SanitaryTerminalTypeShower - Color: Chrome
Pset_DistributionFlowElementCommon - Reference: BC5083-24:BC5083-24; sets with these values: 2
Pset_ElementShading - sets with these values: 2
Pset_ProductRequirements - Category: Plumbing Fixtures
Constraints - Level: Level: Level 0; Moves With Nearby Elements: no; Elevation from Level: 1370.07 mm; Host: Level : Level 0; Offset from Host: 1370.07 mm
Dimensions - Area: 0.0392493 m2; Volume: 0.000424589 m3
Identity Data - Mark: 314
Other - Family: BC5083-24: BC5083-24; Family and Type: BC5083-24: BC5083-24; Type: BC5083-24: BC5083-24; Type Id: BC5083-24: BC5083-24
Phasing - Phase Created: New Construction

# IfcFlowTerminal: BC725:BC725 (2)
In: Level 0
Type - Material: <Unnamed>
Type - Constraints - Default Elevation: 0 mm
Type - Identity Data - AccessibilityPerformance: n/a; AssetIdentifier: n/a; AssetType: Fixed; BarCode: n/a; Category: Pr_40_30_78_15:Clothes hooks; CodePerformance: n/a; Color: Brushed Satin or RALPowderCoated; Constituents: n/a; Description: Clothes hooks; DurationUnit: year; ExpectedLife: n/a; Features: n/a; Finish: Brushed Satin or RALPowderCoated; Form: Wall-mounted; Grade: 304; InstallationDate: 31-12-1900 23:59; Manufacturer: mailto:info@dolphinsolutions.co.uk; ManufacturerName: DolphinsolutionsLimited; ManufacturerURL: http://www.dolphinsolutions.co.uk/; Material: StainlessSteel; ModelNumber: BC725/BC725PC; ModelReference: DolphinSolutionsLimited_ClothesHooks; Name: Clothes hooks_BC725_DolphinSolutionsLimited; NBSDescription: Clothes hooks; NBSReference: 45-35-72/322; NBSTypeID: n/a; NominalHeight: 0; NominalLength: 60; NominalWidth: 48; ObjectClassification_1: OmniClass; ObjectClassification_2: 23.40.20.21.31; OmniClass Number: 23.45.00.00; OmniClass Title: Sanitary, Laundry, and Cleaning Equipment; ProductInformation: https://www.dolphinsolutions.co.uk/product/single-robe-hook-bc725/; ReplacementCost: n/a; Revision: n/a; SerialNumber: n/a; Shape: n/a; Size: 60 x 48 mm; SustainabilityPerformance: n/a; TagNumber: n/a; Type Name: BC725; Uniclass2015Code: Pr_40_30_78_15; Uniclass2015Title: Clothes hooks; WarrantyDescription: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a; WarrantyStartDate: 31-12-1900 23:59
Type - Other - Category: Plumbing Fixtures; Family Name: BC725
Type - Pset_ElementShading - Color: Brushed Satin or RALPowderCoated
Type - Pset_ManufacturerOccurrence - BarCode: n/a; SerialNumber: n/a
Type - Pset_ManufacturerTypeInformation - ModelReference: DolphinSolutionsLimited_ClothesHooks; Manufacturer: mailto:info@dolphinsolutions.co.uk
Type - Pset_ProductRequirements - Name: Clothes hooks_BC725_DolphinSolutionsLimited; Category: Pr_40_30_78_15:Clothes hooks
Pset_DistributionFlowElementCommon - Reference: BC725:BC725; sets with these values: 2
Pset_ProductRequirements - Category: Plumbing Fixtures
Constraints - Level: Level: Level 0; Moves With Nearby Elements: no; Host: Level : Level 0
Dimensions - Area: 0.00466682 m2; Volume: 0.0000330174 m3
Other - Family: BC725: BC725; Family and Type: BC725: BC725; Type: BC725: BC725; Type Id: BC725: BC725
Phasing - Phase Created: New Construction
Name (BC725:BC725:...) | Elevation from Level (mm) = Offset from Host (mm) | Mark
588796 | 1400 | 302
588803 | 1050 | 309

# IfcFlowTerminal: DB1032:DB1032, DB1032:DB1032:588807
In: Level 0
Type - PredefinedType: SHOWER; Material: <Unnamed>
Type - Constraints - Default Elevation: 0 mm
Type - Identity Data - AccessibilityPerformance: n/a; AssetIdentifier: n/a; AssetType: Fixed; BarCode: n/a; Category: Pr_40_20_87_76:Shower heads; CodePerformance: WRAS; Color: Chrome; Constituents: n/a; Description: Shower head wall mounted bottom inlet; DurationUnit: year; ExpectedLife: n/a; Features: Easy clean silicone nozzles; Finish: ChromePlated; IfcExportAs: IfcSanitaryTerminalType; IfcExportType: SHOWER; InstallationDate: 31-12-1900 23:59; Manufacturer: info@dolphinsolutions.co.uk; ManufacturerName: DolphinsolutionsLimited; ManufacturerURL: http://www.dolphinsolutions.co.uk/; Material: ChromePlatedBrass; ModelNumber: DB1032 DB1032 DB1032 DB1032 DB1032; ModelReference: ShowerHeads_DolphinSolutionsLimited_WRAS_DB1032; Name: ShowerHeads_WRAS_DB1032_ShowerHeadWallMountedBottomInlet_DolphinSolutionsLimited; NBSDescription: Showers; NBSReference: 45-35-70/333; NominalHeight: 98 mm; NominalWidth: 62 mm; ObjectClassification1: OmniClass; ObjectClassification2: 23.45.05.14.17; Product Information: https://www.dolphinsolutions.co.uk/product/dolphin-shower-head-wall-mounted-bottom-inlet/; ReplacementCost: n/a; Size: 62x98; SustainabilityPerformance: n/a; TagNumber: n/a; Type Name: DB1032; Uniclass2015Code: Pr_40_20_87_76; Uniclass2015Title: Shower heads; WarrantyDescription: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: 2; WarrantyDurationUnit: year; WarrantyGuarantorLabor: DolphinSolutionsLimited; WarrantyGuarantorParts: DolphinSolutionsLimited; WarrantyStartDate: 31-12-1900 23:59
Type - Other - Category: Plumbing Fixtures; Family Name: DB1032
Type - Pset_ElementShading - Color: Chrome
Type - Pset_ManufacturerOccurrence - BarCode: n/a
Type - Pset_ManufacturerTypeInformation - ModelReference: ShowerHeads_DolphinSolutionsLimited_WRAS_DB1032; Manufacturer: info@dolphinsolutions.co.uk
Type - Pset_ProductRequirements - Name: ShowerHeads_WRAS_DB1032_ShowerHeadWallMountedBottomInlet_DolphinSolutionsLimited; Category: Pr_40_20_87_76:Shower heads
Type - Pset_SanitaryTerminalTypeShower - Color: Chrome
Pset_DistributionFlowElementCommon - Reference: DB1032:DB1032; sets with these values: 2
Pset_ElementShading - sets with these values: 2
Pset_ProductRequirements - Category: Plumbing Fixtures
Constraints - Level: Level: Level 0; Moves With Nearby Elements: no; Elevation from Level: 1763.64 mm; Host: Level : Level 0; Offset from Host: 1763.64 mm
Dimensions - Area: 0.0152555 m2; Volume: 0.000199959 m3
Identity Data - Mark: 313
Other - Family: DB1032: DB1032; Family and Type: DB1032: DB1032; Type: DB1032: DB1032; Type Id: DB1032: DB1032
Phasing - Phase Created: New Construction

# IfcFurnishingElement: BC5083-10:BC5083-10, BC5083-10:BC5083-10:588795
In: Level 0
Type - Material: <Unnamed>
Type - Constraints - Default Elevation: 0 mm
Type - Dimensions - Height: 250mm; Projection: 650mm; Width: 540mm
Type - Identity Data - AccessibilityPerformance: n/a; AssetIdentifier: n/a; AssetType: Fixed; BarCode: n/a; Category: Pr_40_20_06_83:Shower seats; CodePerformance: BSEN12182/DocM/BS8300; Color: Pale grey_white metal; Constituents: n/a; Description: Shower seat; DurationUnit: year; ExpectedLife: n/a; Finish: "BC5083-10 BrushedSatin/WhiteSeat; Grade: 304; IfcExportAs: IfcFurnitureType; IfcExportType: CHAIR; InstallationDate: 31-12-1900 23:59; Manufacturer: info@dolphinsolutions.co.uk; ManufacturerName: DolphinsolutionsLimited; ManufacturerURL: http://www.dolphinsolutions.co.uk/; Material: StainlessSteel_Plastic; ModelNumber: BC5083-10/BC5083-10-PSS/BC5083-10BL/BC5083-10BL-PSS; ModelReference: ShowerSeats_DolphinSolutionsLimited_BC5083-10_ShowerSeat; Name: ShowerSeats_BC5083-10_ShowerSeat_DolphinSolutionsLimited; NBSDescription: Shower seats; NBSReference: 45-35-72/352; NominalHeight: 245 mm; NominalLength: 650 mm; NominalWidth: 540 mm; ObjectClassification1: OmniClass; ObjectClassification2: 23.45.05.14.11.17; Product Information: https://www.dolphinsolutions.co.uk/product/dolphin-doc-m-shower-seat/; ReplacementCost: n/a; Shape: Rectangular; Size: 540x650x245; SustainabilityPerformance: n/a; TagNumber: n/a; Type Name: BC5083-10; Uniclass2015Code: Pr_40_20_06_83; Uniclass2015Title: Shower seats; WarrantyDescription: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: year; WarrantyGuarantorLabor: DolphinSolutionsLimited; WarrantyGuarantorParts: DolphinSolutionsLimited; WarrantyStartDate: 31-12-1900 23:59
Type - Other - Category: Plumbing Fixtures; Family Name: BC5083-10
Type - Pset_ElementShading - Color: Pale grey_white metal
Type - Pset_FurnitureTypeCommon - Description: Shower seat
Type - Pset_ManufacturerOccurrence - BarCode: n/a
Type - Pset_ManufacturerTypeInformation - ModelReference: ShowerSeats_DolphinSolutionsLimited_BC5083-10_ShowerSeat; Manufacturer: info@dolphinsolutions.co.uk
Type - Pset_ProductRequirements - Name: ShowerSeats_BC5083-10_ShowerSeat_DolphinSolutionsLimited; Category: Pr_40_20_06_83:Shower seats
Pset_ProductRequirements - Category: Plumbing Fixtures
Pset_QuantityTakeOff - Reference: BC5083-10:BC5083-10
Constraints - Level: Level: Level 0; Moves With Nearby Elements: no; Elevation from Level: 391.179 mm; Host: Level : Level 0; Offset from Host: 391.179 mm
Dimensions - Area: 0.384577 m2; Volume: 0.00651968 m3
Identity Data - Mark: 301
Other - Family: BC5083-10: BC5083-10; Family and Type: BC5083-10: BC5083-10; Type: BC5083-10: BC5083-10; Type Id: BC5083-10: BC5083-10
Phasing - Phase Created: New Construction

# IfcFurnishingElement: BC5083-11:BC5083-11, BC5083-11:BC5083-11:588793
In: Level 0
Type - Material: <Unnamed>
Type - Constraints - Default Elevation: 0 mm
Type - Dimensions - Length: 1200 mm
Type - Identity Data - AccessibilityPerformance: n/a; AssetIdentifier: n/a; AssetType: Fixed; BarCode: n/a; Category: Pr_40_30_20_77:Shower curtain rails; CodePerformance: n/a; Color: BrushedSatin_Polished_PVD_RAL_PowderCoated_CeramicCoated; Constituents: n/a; Description: Shower curtain rails; DurationUnit: year; ExpectedLife: n/a; Features: Concealed fixings; Finish: Suffix_.1BrushedSatin_.2Polished_.3PVD_.5PowderCoated_.6CeramicCoated; Grade: 304; IfcExportAs: IfcFurnitureType; IfcExportType: USERDEFINED; InstallationDate: 31-12-1900 23:59; Manufacturer: info@dolphinsolutions.co.uk; ManufacturerName: DolphinsolutionsLimited; ManufacturerURL: http://www.dolphinsolutions.co.uk/; Material: StainlessSteel; ModelNumber: BC5083-11; ModelReference: ShowerCurtainRails_DolphinSolutionsLimited_BC5083-11; Name: ShowerCurtainRails_BC5083-11_ShowerCurtainRail_DolphinSolutionsLimited; NBSDescription: Shower curtain rails; NBSReference: 45-35-70/334; NominalLength: 1200 mm; NominalWidth: 1200 mm; ObjectClassification1: OmniClass; ObjectClassification2: 23.45.05.14.17; OmniClass Number: 23.40.20.21.44; OmniClass Title: Shower Rods, Curtains; Product Information: https://www.dolphinsolutions.co.uk/product/dolphin-corner-shower-rail/; ReplacementCost: n/a; Size: 1200x1200; SustainabilityPerformance: n/a; TagNumber: n/a; Type Name: BC5083-11; Uniclass2015Code: Pr_40_30_20_77; Uniclass2015Title: Shower curtain rails; WarrantyDescription: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: year; WarrantyGuarantorLabor: DolphinSolutionsLimited; WarrantyGuarantorParts: DolphinSolutionsLimited; WarrantyStartDate: 31-12-1900 23:59
Type - Other - Category: Plumbing Fixtures; Family Name: BC5083-11
Type - Pset_ElementShading - Color: BrushedSatin_Polished_PVD_RAL_PowderCoated_CeramicCoated
Type - Pset_FurnitureTypeCommon - Description: Shower curtain rails
Type - Pset_ManufacturerOccurrence - BarCode: n/a
Type - Pset_ManufacturerTypeInformation - ModelReference: ShowerCurtainRails_DolphinSolutionsLimited_BC5083-11; Manufacturer: info@dolphinsolutions.co.uk
Type - Pset_ProductRequirements - Name: ShowerCurtainRails_BC5083-11_ShowerCurtainRail_DolphinSolutionsLimited; Category: Pr_40_30_20_77:Shower curtain rails
Pset_ProductRequirements - Category: Plumbing Fixtures
Pset_QuantityTakeOff - Reference: BC5083-11:BC5083-11
Constraints - Elevation from Level: 2025 mm; Host: Level : Level 0; Level: Level: Level 0; Moves With Nearby Elements: no; Offset from Host: 2025 mm
Dimensions - Area: 0.10303 m2; Volume: 0.00124196 m3
Identity Data - Mark: 299
Other - Family: BC5083-11: BC5083-11; Family and Type: BC5083-11: BC5083-11; Type: BC5083-11: BC5083-11; Type Id: BC5083-11: BC5083-11
Phasing - Phase Created: New Construction

# IfcFurnishingElement: BC5083-12:BC5083-12, BC5083-12:BC5083-12:588805
In: Level 0
Type - Material: <Unnamed>
Type - Constraints - Default Elevation: 0 mm
Type - Identity Data - AccessibilityPerformance: n/a; AssetIdentifier: n/a; AssetType: Fixed; BarCode: n/a; Category: Pr_40_30_20_77:Shower curtain rails; CodePerformance: n/a; Color: BrushedSatin_Polished_PVD_RAL_PowderCoated_CeramicCoated; Constituents: n/a; Description: Shower curtain rail ceiling stay; DurationUnit: year; ExpectedLife: n/a; Features: Concealed fixings; Finish: Suffix_.1BrushedSatin_.2Polished_.3PVD_.5PowderCoated_.6CeramicCoated; Grade: 304; IfcExportAs: IfcFurnitureType; IfcExportType: USERDEFINED; InstallationDate: 31-12-1900 23:59; Manufacturer: info@dolphinsolutions.co.uk; ManufacturerName: DolphinsolutionsLimited; ManufacturerURL: http://www.dolphinsolutions.co.uk/; Material: StainlessSteel; ModelNumber: BC5083-12; ModelReference: ShowerCurtainRails_CeilingStay_DolphinSolutionsLimited_BC5083-12; Name: ShowerCurtainRails_BC5083-12_ShowerCurtainRailCeilingStay_DolphinSolutionsLimited; NBSDescription: Shower curtain rails; NBSReference: 45-35-70/334; NominalHeight: 500 mm; NominalWidth: 75 mm; ObjectClassification1: OmniClass; ObjectClassification2: 23.45.05.14.17; OmniClass Number: 23.40.20.21.44; OmniClass Title: Shower Rods, Curtains; Product Information: https://www.dolphinsolutions.co.uk/product/dolphin-ceiling-stay/; ReplacementCost: n/a; Size: 75x500; SustainabilityPerformance: n/a; TagNumber: n/a; Type Name: BC5083-12; Uniclass2015Code: Pr_40_30_20_77; Uniclass2015Title: Shower curtain rails; WarrantyDescription: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: year; WarrantyGuarantorLabor: DolphinSolutionsLimited; WarrantyGuarantorParts: DolphinSolutionsLimited; WarrantyStartDate: 31-12-1900 23:59
Type - Other - Category: Plumbing Fixtures; Family Name: BC5083-12
Type - Pset_ElementShading - Color: BrushedSatin_Polished_PVD_RAL_PowderCoated_CeramicCoated
Type - Pset_FurnitureTypeCommon - Description: Shower curtain rail ceiling stay
Type - Pset_ManufacturerOccurrence - BarCode: n/a
Type - Pset_ManufacturerTypeInformation - ModelReference: ShowerCurtainRails_CeilingStay_DolphinSolutionsLimited_BC5083-12; Manufacturer: info@dolphinsolutions.co.uk
Type - Pset_ProductRequirements - Name: ShowerCurtainRails_BC5083-12_ShowerCurtainRailCeilingStay_DolphinSolutionsLimited; Category: Pr_40_30_20_77:Shower curtain rails
Pset_ProductRequirements - Category: Plumbing Fixtures
Pset_QuantityTakeOff - Reference: BC5083-12:BC5083-12
Constraints - Level: Level: Level 0; Moves With Nearby Elements: no; Elevation from Level: 2500 mm; Host: Level : Level 0; Offset from Host: 2500 mm
Dimensions - Area: 0.00895278 m2; Volume: 0.0000298871 m3
Identity Data - Mark: 311
Other - Family: BC5083-12: BC5083-12; Family and Type: BC5083-12: BC5083-12; Type: BC5083-12: BC5083-12; Type Id: BC5083-12: BC5083-12
Phasing - Phase Created: New Construction

# IfcFurnishingElement: BC5083-13:BC5083-13 (24)
In: Level 0
Type - Material: <Unnamed>
Type - Constraints - Default Elevation: 0 mm
Type - Identity Data - AccessibilityPerformance: n/a; AssetIdentifier: n/a; AssetType: Fixed; BarCode: n/a; CodePerformance: n/a; Color: Chrome; Constituents: n/a; Description: Shower curtain hooks; DurationUnit: year; ExpectedLife: n/a; Features: n/a; Finish: Chrome Plated; Grade: 304; IfcExportAs: IfcFurnitureType; IfcExportType: USERDEFINED; InstallationDate: 31-12-1900 23:59; Manufacturer: info@dolphinsolutions.co.uk; ManufacturerName: DolphinsolutionsLimited; ManufacturerURL: http://www.dolphinsolutions.co.uk/; Material: Brass Chrome Plated; ModelNumber: BC5083-13; ModelReference: ShowerCurtainHooks_DolphinSolutionsLimited_BC5083-13; Name: ShowerCurtainHooks_BC5083-13_DolphinSolutionsLimited; ObjectClassification1: OmniClass; ObjectClassification2: 23.45.05.14.17; OmniClass Number: 23.40.20.21.44; OmniClass Title: Shower Rods, Curtains; Product Information: https://www.dolphinsolutions.co.uk/product/dolphin-curtain-hooks-brass-chrome-plated/; ReplacementCost: n/a; SustainabilityPerformance: n/a; TagNumber: n/a; Type Name: BC5083-13; WarrantyDescription: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: year; WarrantyGuarantorLabor: DolphinSolutionsLimited; WarrantyGuarantorParts: DolphinSolutionsLimited; WarrantyStartDate: 31-12-1900 23:59
Type - Other - Category: Plumbing Fixtures; Family Name: BC5083-13
Type - Pset_ElementShading - Color: Chrome
Type - Pset_FurnitureTypeCommon - Description: Shower curtain hooks
Type - Pset_ManufacturerOccurrence - BarCode: n/a
Type - Pset_ManufacturerTypeInformation - ModelReference: ShowerCurtainHooks_DolphinSolutionsLimited_BC5083-13; Manufacturer: info@dolphinsolutions.co.uk
Type - Pset_ProductRequirements - Name: ShowerCurtainHooks_BC5083-13_DolphinSolutionsLimited
Pset_ProductRequirements - Category: Plumbing Fixtures
Pset_QuantityTakeOff - Reference: BC5083-13:BC5083-13
Constraints - Level: Level: Level 0; Moves With Nearby Elements: no; Elevation from Level: 2025 mm; Host: Level : Level 0; Offset from Host: 2025 mm
Dimensions - Area: 0.0013773 m2; Volume: 0.00000205534 m3
Other - Family: BC5083-13: BC5083-13; Family and Type: BC5083-13: BC5083-13; Type: BC5083-13: BC5083-13; Type Id: BC5083-13: BC5083-13
Phasing - Phase Created: New Construction
Name (BC5083-13:BC5083-13:...) | Mark
588813 | 319
588814 | 320
588815 | 321
588816 | 322
588817 | 323
588818 | 324
588819 | 325
588820 | 326
588821 | 327
588822 | 328
588823 | 329
588824 | 330
588826 | 332
588827 | 333
588828 | 334
588829 | 335
588830 | 336
588831 | 337
588832 | 338
588833 | 339
588834 | 340
588835 | 341
588836 | 342
588837 | 343

# IfcFurnishingElement: BC5083-14:BC5083-14 (2)
In: Level 0
Type - Material: <Unnamed>
Type - Constraints - Default Elevation: 0 mm
Type - Identity Data - AccessibilityPerformance: n/a; AssetIdentifier: n/a; AssetType: Fixed; BarCode: n/a; CodePerformance: n/a; Color: White; Constituents: n/a; Description: Shower curtain; DurationUnit: year; ExpectedLife: n/a; Features: n/a; Finish: n/a; Grade: 304; IfcExportAs: IfcFurnitureType; IfcExportType: USERDEFINED; InstallationDate: 31-12-1900 23:59; Manufacturer: info@dolphinsolutions.co.uk; ManufacturerName: DolphinsolutionsLimited; ManufacturerURL: http://www.dolphinsolutions.co.uk/; Material: 4oz Weighted White Polyester; ModelNumber: BC5083-14; ModelReference: ShowerCurtain_DolphinSolutionsLimited_BC5083-14; Name: ShowerCurtain_BC5083-14_DolphinSolutionsLimited; NominalHeight: 1830 mm; NominalLength: 1830 mm; ObjectClassification1: OmniClass; ObjectClassification2: 23.45.05.14.17; OmniClass Number: 23.40.20.21.44; OmniClass Title: Shower Rods, Curtains; Product Information: https://www.dolphinsolutions.co.uk/product/dolphin-shower-curtain/; ReplacementCost: n/a; Size: 1830x1830; SustainabilityPerformance: n/a; TagNumber: n/a; Type Name: BC5083-14; WarrantyDescription: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: year; WarrantyGuarantorLabor: DolphinSolutionsLimited; WarrantyGuarantorParts: DolphinSolutionsLimited; WarrantyStartDate: 31-12-1900 23:59
Type - Other - Category: Plumbing Fixtures; Family Name: BC5083-14
Type - Pset_ElementShading - Color: White
Type - Pset_FurnitureTypeCommon - Description: Shower curtain
Type - Pset_ManufacturerOccurrence - BarCode: n/a
Type - Pset_ManufacturerTypeInformation - ModelReference: ShowerCurtain_DolphinSolutionsLimited_BC5083-14; Manufacturer: info@dolphinsolutions.co.uk
Type - Pset_ProductRequirements - Name: ShowerCurtain_BC5083-14_DolphinSolutionsLimited
Pset_ProductRequirements - Category: Plumbing Fixtures
Pset_QuantityTakeOff - Reference: BC5083-14:BC5083-14
Constraints - Level: Level: Level 0; Moves With Nearby Elements: no; Elevation from Level: 125 mm; Host: Level : Level 0; Offset from Host: 125 mm
Dimensions - Area: 1.91829 m2; Volume: 0.00191533 m3
Other - Family: BC5083-14: BC5083-14; Family and Type: BC5083-14: BC5083-14; Type: BC5083-14: BC5083-14; Type Id: BC5083-14: BC5083-14
Phasing - Phase Created: New Construction
Name (BC5083-14:BC5083-14:...) | Mark
588812 | 318
588825 | 331

# IfcFurnishingElement: BC5083-37:BC5083-37, BC5083-37:BC5083-37:588794
In: Level 0
Type - Material: <Unnamed>
Type - Constraints - Default Elevation: 0 mm
Type - Dimensions - Depth: 223 mm; Height: 160 mm; Width: 400 mm
Type - Identity Data - AccessibilityPerformance: n/a; AssetIdentifier: n/a; AssetType: Fixed; BarCode: n/a; Category: Pr_40_20_06_83:Shower seats; Color: BrushedSatin/MirrorPolished_White/Black; Constituents: n/a; Description: Shower seat back rest; DurationUnit: year; ExpectedLife: n/a; Finish: n/a; Grade: 304; IfcExportAs: IfcFurnitureType; IfcExportType: USERDEFINED; InstallationDate: 31-12-1900 23:59; Manufacturer: info@dolphinsolutions.co.uk; ManufacturerName: DolphinsolutionsLimited; ManufacturerURL: http://www.dolphinsolutions.co.uk/; Material: StainlessSteel/Vinyl; ModelNumber: BC5083-37-WH/BC5083-37-BLK; ModelReference: ShowerSeat_DolphinSolutionsLimited_BC5083-37_ShowerSeatBackRest; Name: ShowerSeat_BC5083-37_ShowerSeatBackRest_DolphinSolutionsLimited; NBSDescription: Shower seats; NBSReference: 45-35-72/352; NominalHeight: 100 mm; NominalLength: 233 mm; NominalWidth: 400 mm; ObjectClassification1: OmniClass; ObjectClassification2: 23.45.05.14.11.17; Product Information: https://www.dolphinsolutions.co.uk/product/dolphin-stainless-steel-padded-backrest-2/; ReplacementCost: n/a; Shape: Rectangular; Size: 400x233x100; SustainabilityPerformance: n/a; TagNumber: n/a; Type Name: BC5083-37; Uniclass2015Code: Pr_40_20_06_83; Uniclass2015Title: Shower seats; WarrantyDescription: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: year; WarrantyGuarantorLabor: DolphinSolutionsLimited; WarrantyGuarantorParts: DolphinSolutionsLimited; WarrantyStartDate: 31-12-1900 23:59
Type - Other - Category: Plumbing Fixtures; Family Name: BC5083-37
Type - Pset_ElementShading - Color: BrushedSatin/MirrorPolished_White/Black
Type - Pset_FurnitureTypeCommon - Description: Shower seat back rest
Type - Pset_ManufacturerOccurrence - BarCode: n/a
Type - Pset_ManufacturerTypeInformation - ModelReference: ShowerSeat_DolphinSolutionsLimited_BC5083-37_ShowerSeatBackRest; Manufacturer: info@dolphinsolutions.co.uk
Type - Pset_ProductRequirements - Name: ShowerSeat_BC5083-37_ShowerSeatBackRest_DolphinSolutionsLimited; Category: Pr_40_20_06_83:Shower seats
Pset_ProductRequirements - Category: Plumbing Fixtures
Pset_QuantityTakeOff - Reference: BC5083-37:BC5083-37
Constraints - Level: Level: Level 0; Moves With Nearby Elements: no; Elevation from Level: 720 mm; Host: Level : Level 0; Offset from Host: 720 mm
Dimensions - Area: 0.115205 m2; Volume: 0.00343444 m3
Identity Data - Mark: 300
Other - Family: BC5083-37: BC5083-37; Family and Type: BC5083-37: BC5083-37; Type: BC5083-37: BC5083-37; Type Id: BC5083-37: BC5083-37
Phasing - Phase Created: New Construction

# IfcFurnishingElement: BC5084-06:BC5084-06 (2)
In: Level 0
Type - Material: <Unnamed>
Type - Constraints - Default Elevation: 0 mm
Type - Identity Data - AccessibilityPerformance: n/a; AssetIdentifier: n/a; AssetType: Fixed; BarCode: n/a; Category: Pr_40_20_76_84:SupportRails; CodePerformance: BSEN12182_DocM_BS8300; Color: Brushed Satin/Mirror Polished; Constituents: n/a; Description: 800mm Hinged Fold Down Grab Rail; DurationUnit: year; ExpectedLife: n/a; Features: 800mm Fold Down; Finish: Brushed Satin/Mirror Polished; Form: Wall-mounted; Grade: 304; IfcExportAs: IfcFurnitureType; IfcExportType: USERDEFINED; InstallationDate: 31-12-1900 23:59; Manufacturer: info@dolphinsolutions.co.uk; ManufacturerName: DolphinsolutionsLimited; ManufacturerURL: http://www.dolphinsolutions.co.uk/; Material: StainlessSteel; ModelNumber: BC5084-06/BC5084-06-PSS; ModelReference: DolphinSolutionsLimited_32mmGrabRail_BC5084-06; Name: SupportRails_800mmFoldHingedDown32mmGrabRail_BC5084-06_DolphinSolutionsLimited; NBSDescription: Support rails; NBSReference: 45-35-72/360; NBSTypeID: n/a; NominalHeight: 245 mm; NominalLength: 800 mm; NominalWidth: 100 mm; ObjectClassification1: OmniClass; ObjectClassification2: 23.40.20.27.14; ProductInformation: https://www.dolphinsolutions.co.uk/product/bc5084-06-bc5084-06pss-bc5084-06650-bc5084-06650-pss-dolphin-stainless-steel-hinged-rail-with-friction-mechanism/; ReplacementCost: n/a; Revision: n/a; SerialNumber: n/a; Shape: n/a; Size: 800 x 100 x 245 mm; SustainabilityPerformance: n/a; TagNumber: n/a; Type Name: BC5084-06; Uniclass2015Code: Pr_40_20_76_84; Uniclass2015Title: Support rails; WarrantyDescription: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a; WarrantyStartDate: 31-12-1900 23:59
Type - Other - Category: Plumbing Fixtures; Family Name: BC5084-06
Type - Pset_ElementShading - Color: Brushed Satin/Mirror Polished
Type - Pset_FurnitureTypeCommon - Description: 800mm Hinged Fold Down Grab Rail
Type - Pset_ManufacturerOccurrence - BarCode: n/a; SerialNumber: n/a
Type - Pset_ManufacturerTypeInformation - ModelReference: DolphinSolutionsLimited_32mmGrabRail_BC5084-06; Manufacturer: info@dolphinsolutions.co.uk
Type - Pset_ProductRequirements - Name: SupportRails_800mmFoldHingedDown32mmGrabRail_BC5084-06_DolphinSolutionsLimited; Category: Pr_40_20_76_84:SupportRails
Pset_ProductRequirements - Category: Plumbing Fixtures
Pset_QuantityTakeOff - Reference: BC5084-06:BC5084-06
Constraints - Level: Level: Level 0; Moves With Nearby Elements: no; Elevation from Level: 585 mm; Host: Level : Level 0; Offset from Host: 585 mm
Dimensions - Area: 0.132752 m2; Volume: 0.00171578 m3
Other - Family: BC5084-06: BC5084-06; Family and Type: BC5084-06: BC5084-06; Type: BC5084-06: BC5084-06; Type Id: BC5084-06: BC5084-06
Phasing - Phase Created: New Construction
Name (BC5084-06:BC5084-06:...) | Mark
588797 | 303
588802 | 308

# IfcRailing: BC5083-05:BC5083-05, BC5083-05:BC5083-05:588838
In: Level 0
Type - PredefinedType: HANDRAIL; Material: <Unnamed>
Type - Constraints - Default Elevation: 0 mm
Type - Dimensions - Heigth: 92 mm; Length: 500 mm; Width: 32 mm
Type - Identity Data - AccessibilityPerformance: n/a; AssetIdentifier: n/a; AssetType: Fixed; BarCode: n/a; Category: Pr_40_20_76_84:SupportRails; CAWS: N13/69 Support rails and grab bars_N13/436 Handrails and grab bars; CodePerformance: BSEN12182; Color: Brushed Satin_Various; Constituents: n/a; Description: 500mm long flanged 32mm grab rail; DurationUnit: year; ExpectedLife: n/a; Features: Flanged 60mm wall clearance; Finish: Brushed Satin_Suffix.5-PowderCoated_.6-CeramicCoated; Form: Wall-mounted; Grade: 304; IfcExportAs: IfcRailingType; IfcExportType: HANDRAIL; InstallationDate: 31-12-1900 23:59:59; Manufacturer: info@dolphinsolutions.co.uk; ManufacturerName: DolphinsolutionsLimited; ManufacturerURL: Dolphin Solutions Limited; Material: StainlessSteel; ModelNumber: BC5083-05; ModelReference: DolphinSolutionsLimited_Flanged32mmGrabRail; Name: SupportRails_Flanged32mmGrabRail_BC5083-05_DolphinSolutionsLimited; NBSDescription: Support rails; NBSReference: 45-35-72/360; NBSTypeID: n/a; NominalHeight: 92 mm; NominalLength: 500 mm; NominalWidth: 32 mm; ObjectClassification: 23.40.20.27.14; OmniClass Number: 23.45.00.00; OmniClass Title: Sanitary, Laundry, and Cleaning Equipment; ReplacementCost: n/a; Revision: n/a; SerialNumber: n/a; Shape: n/a; Size: 500 x 32 x 92 mm; SustainabilityPerformance: n/a; TagNumber: n/a; Type Name: BC5083-05; Uniclass2015Code: Pr_40_20_76_84; Uniclass2015Title: Support rails; WarrantyDescription: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a; WarrantyStartDate: 31-12-1900 23:59:59
Type - Other - Category: Plumbing Fixtures; Family Name: BC5083-05
Type - Pset_ElementShading - Color: Brushed Satin_Various
Type - Pset_ManufacturerOccurrence - BarCode: n/a; SerialNumber: n/a
Type - Pset_ManufacturerTypeInformation - ModelReference: DolphinSolutionsLimited_Flanged32mmGrabRail; Manufacturer: info@dolphinsolutions.co.uk
Type - Pset_PrecastConcreteElementGeneral - SerialNumber: n/a
Type - Pset_ProductRequirements - Name: SupportRails_Flanged32mmGrabRail_BC5083-05_DolphinSolutionsLimited; Category: Pr_40_20_76_84:SupportRails
Type - Pset_RailingCommon - IsExternal: no
Pset_ProductRequirements - Category: Plumbing Fixtures
Pset_QuantityTakeOff - Reference: BC5083-05:BC5083-05
Pset_RailingCommon - Reference: BC5083-05:BC5083-05
Constraints - Level: Level: Level 0; Moves With Nearby Elements: no; Elevation from Level: 665 mm; Host: Level : Level 0; Offset from Host: 665 mm
Dimensions - Area: 0.0552755 m2; Volume: 0.000548794 m3
Identity Data - Mark: 344
Other - Family: BC5083-05: BC5083-05; Family and Type: BC5083-05: BC5083-05; Type: BC5083-05: BC5083-05; Type Id: BC5083-05: BC5083-05
Phasing - Phase Created: New Construction
